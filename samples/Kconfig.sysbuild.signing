## samples/boards/circuitdojo/feather_nrf9151/Kconfig.sysbuild
```kconfig
# Copyright (c) 2026 Circuit Dojo LLC
# SPDX-License-Identifier: Apache-2.0

config PARTITION_MANAGER
	bool
	default n
```
